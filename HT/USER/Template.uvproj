# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  AfterMake: fromelf.exe --bin -o ..\Template.bin ..\OBJ\Template.axf
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\UART2;..\FreeModbus\modbus\ascii;..\FreeModbus\modbus\functions;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\FreeModbus\modbus\tcp;..\FreeModbus\port;..\HARDWARE\LED;..\HARDWARE\APP;..\HARDWARE\FLASH;..\HARDWARE\AD5410\inc;..\HARDWARE\LTC2440\inc;..\HARDWARE\temperature\inc;..\SYSTEM\delay;..\HARDWARE\G;..\HARDWARE\LTC2630ISC6;..\HARDWARE\SWITCH;..\HARDWARE\ADC;..\HARDWARE\tur;..\HARDWARE\COLOR
  memory RVCT4: ROM 0x8003000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/APP/: app.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/tur/: tur.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group FreeModBus
    ../FreeModbus/modbus/: mb.c
    ../FreeModbus/modbus/ascii/: mbascii.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/tcp/: mbtcp.c
  group FreeModBus_Port
    ../FreeModbus/port/: portevent.c portserial.c porttimer.c embreg.c
  group HW
    ../HARDWARE/LTC2630ISC6/: LTC2630ISC6.C
    ../HARDWARE/SWITCH/: SWITCH.C
    ../HARDWARE/ADC/: ADC.C
    ../HARDWARE/COLOR/: color.c
